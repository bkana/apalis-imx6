RRECOMMENDS:${PN}:append:imxgpu:tdx = " ${PN}-vivante"
