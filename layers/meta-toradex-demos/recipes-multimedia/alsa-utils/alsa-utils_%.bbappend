PACKAGECONFIG:append = " bat"
