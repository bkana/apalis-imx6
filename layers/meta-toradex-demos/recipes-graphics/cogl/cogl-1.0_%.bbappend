# Workaround populate_sdk issue which depends on cogl-1.0 which can not be
# found.
RDEPENDS:${PN}-dev = ""
