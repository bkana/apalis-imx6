FILESEXTRAPATHS:prepend := "${THISDIR}/lxqt-session:"

SRC_URI += "file://0001-session.conf-add-qterminal-as-default-terminal.patch"
