FILESEXTRAPATHS:prepend := "${THISDIR}/pcmanfm-qt:"

SRC_URI += "file://0001-settings.conf.in-change-to-use-a-toradex-wallpaper.patch"
