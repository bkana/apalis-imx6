PACKAGECONFIG:remove:am62xx = "wayland-vulkan-server-buffer xcomposite-egl xcomposite-glx"
PACKAGE_ARCH:am62xx = "${MACHINE_ARCH}"
