PACKAGECONFIG:remove:am62xx = "glamor glx"
PACKAGE_ARCH:am62xx = "${MACHINE_ARCH}"
