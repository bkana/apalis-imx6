PACKAGE_ARCH:am62xx = "${MACHINE_ARCH}"
